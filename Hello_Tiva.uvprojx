# Keil uVision project Hello_Tiva.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hello_Tiva +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 wLevel=2
  c include: .\01-Library;.\02-MCAL\01_Sys_Ctrl_clk;.\02-MCAL\02_IntCtrl;.\02-MCAL\03_Sys_Tick;.\02-MCAL\04_Port;.\02-MCAL\05_DIO;.\02-MCAL\06_EXTI;.\03_HAL\01-LED
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./04-APP/: main.c
  group MCAL
    ./02-MCAL/01_Sys_Ctrl_clk/: Sys_CtrlClk_program.c
    ./02-MCAL/02_IntCtrl/: NVIC_Program.c
    ./02-MCAL/03_Sys_Tick/: SysTick_Program.c
    ./02-MCAL/04_Port/: Port_Lcfg.c Port_Program.c
    ./02-MCAL/05_DIO/: DIO_Progarm.c
    ./02-MCAL/06_EXTI/: EXTI_Program.c
  group Libraries
    ./01-Library/: StdTypes.h Utlies.h
  group HAL
    ./03_HAL/01-LED/: LED_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
